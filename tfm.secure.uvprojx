# Keil uVision project tfm.secure.uvprojx, settings and files
target secure (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: tfm_s
  c flags: Optim=1 v6Lang=3 v6LangP=1 wLevel=1
  c misc: -g
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ./bsp/tfm_s.sct
  link misc: --cpu=Cortex-M55 --info=summarysizes,sizes,totals,unused,veneers --diag_suppress=6312 --diag_suppress=6314 --diag_suppress=6304 --diag_suppress=6329 --entry=Reset_Handler --summary_stderr --load_addr_map_info --import_cmse_lib_out=./build/secure_partition/s_veneers.o
  group qcbor
    ./lib/tf-m/lib/ext/qcbor/src/: ieee754.c qcbor_decode.c qcbor_encode.c UsefulBuf.c
    ./lib/tf-m/lib/ext/qcbor/util/: qcbor_util.c
  group t_cose
    ./lib/tf-m/lib/ext/t_cose/src/: t_cose_parameters.c t_cose_sign1_sign.c t_cose_sign1_verify.c t_cose_util.c
    ./lib/tf-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group libplatform_s
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/cmsis_drivers/: Driver_AN547_MPC.c Driver_Flash.c Driver_SSE300_PPC.c Driver_USART.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: device_definition.c system_core_init.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/native_drivers/: mpc_sie_drv.c mpu_armv8m_drv.c ppc_sse300_drv.c syscounter_armv8-m_cntrl_drv.c systimer_armv8-m_drv.c uart_cmsdk_drv.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/: spm_hal.c target_cfg.c tfm_hal_isolation.c plat_test.c
    ./lib/tf-m/platform/ext/common/: tfm_hal_isolation_mpu_v8m.c tfm_hal_ps.c tfm_hal_its.c tfm_platform.c uart_stdout.c tfm_hal_memory_symbols.c tfm_hal_spm_logdev_peripheral.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/services/src/: tfm_platform_system.c
    ./lib/tf-m/platform/ext/common/template/: attest_hal.c nv_counters.c crypto_keys.c tfm_rotpk.c tfm_initial_attestation_key_material.c
    ./lib/tf-m/interface/src/log/: tfm_log_raw.c
  group tfm_psa_rot_partition_platform
    ./lib/tf-m/secure_fw/partitions/platform/: platform_sp.c
  group tfm_psa_rot_partition_its
    ./lib/tf-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs_mblock.c its_flash_fs_dblock.c its_flash_fs.c
    ./lib/tf-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash_ram.c its_flash_nor.c its_flash_nand.c its_flash.c
    ./lib/tf-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c tfm_internal_trusted_storage.c tfm_its_req_mngr.c
  group tfm_app_rot_partition_ps
    ./lib/tf-m/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.c
    ./lib/tf-m/secure_fw/partitions/protected_storage/: ps_encrypted_object.c ps_utils.c ps_object_table.c ps_object_system.c tfm_protected_storage.c tfm_ps_req_mngr.c
    ./lib/tf-m/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c
  group tfm_psa_rot_partition_attestation
    ./lib/tf-m/secure_fw/partitions/initial_attestation/: attest_token_encode.c attest_asymmetric_key.c attest_core.c tfm_attest_req_mngr.c tfm_attest.c
  group crypto_service_mbedcrypto
    ./lib/mbedcrypto/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher_wrap.c cipher.c cmac.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp_curves.c ecp.c entropy_poll.c entropy.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c nist_kw.c oid.c padlock.c pem.c pk_wrap.c pk.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform_util.c platform.c poly1305.c psa_its_file.c ripemd160.c rsa_alt_helpers.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version_features.c version.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c
    ./lib/tf-m/secure_fw/partitions/crypto/: tfm_mbedcrypto_alt.c
  group tfm_psa_rot_partition_crypto
    ./lib/tf-m/platform/ext/common/template/: crypto_dummy_nv_seed.c crypto_nv_seed.c
    ./lib/tf-m/secure_fw/partitions/crypto/: crypto_rng.c crypto_key_derivation.c crypto_asymmetric.c crypto_aead.c crypto_key.c crypto_mac.c crypto_cipher.c crypto_hash.c crypto_alloc.c crypto_init.c
  group tfm_psa_rot_partition_audit
    ./lib/tf-m/secure_fw/partitions/audit_logging/: audit_core.c
  group bootutil
    ./lib/mcuboot/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group bl2
    ./lib/tf-m/bl2/src/: security_cnt.c flash_map.c
    ./lib/tf-m/bl2/ext/mcuboot/: keys.c flash_map_extended.c flash_map_legacy.c
  group tfm_sprt
    ./lib/tf-m/secure_fw/partitions/firmware_update/bootloader/mcuboot/: tfm_mcuboot_fwu.c
    ./lib/tf-m/secure_fw/partitions/firmware_update/: tfm_fwu_secure_api.c tfm_fwu_req_mngr.c tfm_fwu.c
    ./lib/tf-m/secure_fw/partitions/platform/: tfm_platform_secure_api.c
    ./lib/tf-m/secure_fw/partitions/internal_trusted_storage/: tfm_its_secure_api.c
    ./lib/tf-m/secure_fw/partitions/protected_storage/: tfm_ps_secure_api.c
    ./lib/tf-m/secure_fw/partitions/initial_attestation/: tfm_attest_secure_api.c
    ./lib/tf-m/secure_fw/partitions/crypto/: tfm_crypto_secure_api.c
    ./lib/tf-m/secure_fw/partitions/audit_logging/: tfm_audit_secure_api.c
    ./lib/tf-m/platform/ext/common/: tfm_hal_sp_logdev_periph.c
    ./lib/tf-m/secure_fw/partitions/lib/sprt/: tfm_sp_log_raw.c service_api.c crt_memset.c crt_memmove.c crt_memcpy.c crt_memcmp.c
  group tfm_spm
    ./lib/tf-m/secure_fw/spm/cmsis_func/: tfm_secure_api.c tfm_nspm_func.c tfm_core_svcalls_func.c spm_func.c arch.c main.c
    ./lib/tf-m/secure_fw/spm/ffm/: tfm_core_mem_check.c spm_log.c utilities.c tfm_core_utils.c tfm_boot_data.c
  group tfm_fih
    ./lib/tf-m/lib/fih/src/: fih.c
  group tfm_s
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: startup_an547_s.c
    ./bsp/secure_fw/spm/cmsis_func/: tfm_veneers.c

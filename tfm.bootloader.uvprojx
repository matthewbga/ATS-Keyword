# Keil uVision project tfm.bootloader.uvprojx, settings and files
target bootloader (ARM-ADS)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: bl2
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --target=arm-arm-none-eabi -mcpu=cortex-m55+nofp+nodsp+nomve -mfloat-abi=soft
  c include: ./lib/tf-m
  memory RVCT4: RAM 0x10000000 size 0x200000
  memory RVCT5: RAM 0x0 size 0x200000
  memory RVCT9: ROM 0x30000000 size 0x20000
  memory RVCT10: ROM 0x20000000 size 0x20000
  scatter file: ./bsp/an547_bl2.sct
  link misc: --cpu=8.1-M.Main --info=summarysizes,sizes,totals,unused,veneers --diag_suppress=6312 --diag_suppress=6314 --diag_suppress=6304 --diag_suppress=6329 --fpu=softvfp
  group platform_an547_bl2
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/cmsis_drivers/: Driver_Flash.c Driver_USART.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: device_definition.c system_core_init.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/native_drivers/: uart_cmsdk_drv.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/: boot_hal.c
  group platform_bl2
    ./lib/tf-m/platform/ext/common/: boot_hal.c uart_stdout.c
    ./lib/tf-m/platform/ext/common/template/: nv_counters.c tfm_rotpk.c tfm_initial_attestation_key_material.c
  group bl2_mbedcrypto
    ./lib/mbedcrypto/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c
  group bootutil
    ./lib/mcuboot/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group bl2
    ./lib/tf-m/bl2/src/: security_cnt.c flash_map.c shared_data.c
    ./lib/tf-m/bl2/ext/mcuboot/: bl2_main.c keys.c flash_map_extended.c flash_map_legacy.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: startup_an547_bl2.c
